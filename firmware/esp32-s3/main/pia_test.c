#include "pia_crypto.h"
#include <stdio.h>
#define ZSTD_STATIC_LINKING_ONLY
#include "zstd.h"
#include "esp_heap_caps.h"
#include "esp_system.h"

/* A datagram captured from a real Switch session, with the plaintext an independent
   implementation produced for it. Exercises key derivation, nonce construction, tag
   placement and the zstd body in one shot -- the parts where a silent mistake would
   otherwise surface only as an unexplained desync on hardware. */
static const uint8_t kSsid[16] = {
    0x4f, 0x3b, 0x51, 0x39, 0x85, 0xd8, 0x3e, 0xda, 0x42, 0x14, 0xc2, 0xa1,
    0xe6, 0xd4, 0xea, 0x54,
};
static const char kSourceIp[] = "169.254.47.1";
static const uint8_t kDatagram[] = {
    0x32, 0xab, 0x98, 0x64, 0x90, 0x83, 0x00, 0x00, 0x59, 0x6e, 0x00, 0x00,
    0x00, 0xea, 0x57, 0xd4, 0x38, 0x70, 0xe9, 0xdc, 0xd8, 0xb1, 0xe7, 0x15,
    0x26, 0x82, 0x22, 0x03, 0x86, 0x8a, 0x4a, 0xfa, 0xde, 0x94, 0x96, 0x3c,
    0x60, 0xc0, 0x49, 0xb7, 0x22, 0x61, 0x40, 0x1b, 0x30, 0x24, 0xa3, 0x38,
    0x72, 0x5d, 0x01, 0x8f, 0xff, 0xf7, 0xa2, 0x57, 0x6a, 0x45, 0x6a, 0x40,
    0xa3, 0x47, 0xbb, 0x9a, 0x28, 0x63, 0xb6, 0xde, 0x09, 0xd0, 0x5a, 0x95,
    0xba, 0x68, 0x42, 0x25, 0x58, 0xcc, 0xd9, 0xfc, 0x24, 0x77, 0xf8, 0xbb,
    0x1e, 0x2f, 0xab, 0x05, 0xb7, 0xd8, 0xbf, 0x9b, 0x8e, 0xe7, 0xf0, 0xae,
    0x80, 0x77, 0x1d, 0x29, 0xc7, 0x22, 0x17, 0x58, 0x5f, 0xef, 0x2a, 0xb8,
    0x97,
};
static const uint8_t kPlain[] = {
    0x28, 0xb5, 0x2f, 0xfd, 0x00, 0x18, 0xfd, 0x01, 0x00, 0xa4, 0x02, 0x06,
    0x00, 0xa2, 0x01, 0x01, 0x11, 0x00, 0x84, 0x00, 0x00, 0x00, 0x02, 0x59,
    0x6e, 0xca, 0x0c, 0x06, 0xea, 0xf9, 0x74, 0x00, 0x1d, 0xce, 0xd8, 0x91,
    0x01, 0x00, 0x06, 0x00, 0xa9, 0xfe, 0x2f, 0x01, 0x00, 0x30, 0x39, 0x00,
    0x01, 0x02, 0xff, 0x00, 0x00, 0x08, 0x00, 0x07, 0x12, 0xc1, 0x10, 0x33,
    0xb9, 0x03, 0xcd, 0x72, 0xb6, 0x0c, 0x42, 0x03, 0xc6, 0x0b, 0x80, 0x09,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
};

int pia_selftest(char *out, size_t cap)
{
    pia_crypto_t c;
    pia_crypto_init(&c, kSsid);

    static uint8_t plain[PIA_MAX_BODY];
    int n = pia_decrypt(&c, kDatagram, sizeof(kDatagram), kSourceIp, plain, sizeof(plain));
    if (n < 0) return snprintf(out, cap, "decrypt=FAIL");
    const size_t need = ZSTD_estimateDCtxSize();
    const size_t heap = esp_get_free_heap_size();
    const size_t largest = heap_caps_get_largest_free_block(MALLOC_CAP_8BIT);
    if (n != (int)sizeof(kPlain) || memcmp(plain, kPlain, (size_t)n) != 0)
        return snprintf(out, cap, "decrypt=MISMATCH len=%d expected=%u", n, (unsigned)sizeof(kPlain));

    /* The header's low bit marks a compressed body. */
    static uint8_t body[PIA_MAX_BODY];
    int padding = kDatagram[5] >> 4, footer = kDatagram[12];
    int trimmed = n - padding - footer;
    if (trimmed < 0) return snprintf(out, cap, "decrypt=OK footer=BAD");
    int m = (kDatagram[5] & 1) ? pia_decompress(plain, (size_t)trimmed, body, sizeof(body)) : trimmed;
    if (m < 0) return snprintf(out, cap, "decrypt=OK unzip=FAIL dctx_needs=%u heap=%u largest=%u",
                               (unsigned)need, (unsigned)heap, (unsigned)largest);
    if (!(kDatagram[5] & 1)) memcpy(body, plain, (size_t)trimmed);

    pia_message_t messages[PIA_MAX_MESSAGES];
    int count = pia_messages_decode(body, (size_t)m, messages, PIA_MAX_MESSAGES);

    /* A raw-block frame must survive our own decoder. */
    static uint8_t round[PIA_MAX_BODY];
    static uint8_t back[PIA_MAX_BODY];
    int r = pia_compress_raw(kPlain, 32, round, sizeof(round));
    int rb = r > 0 ? pia_decompress(round, (size_t)r, back, sizeof(back)) : -1;
    bool raw_ok = rb == 32 && memcmp(back, kPlain, 32) == 0;

    return snprintf(out, cap, "decrypt=OK plain=%d unzip=%d messages=%d proto0=%u rawframe=%s "
                    "dctx_needs=%u heap=%u largest=%u",
                    n, m, count, count > 0 ? messages[0].protocol : 0, raw_ok ? "OK" : "FAIL",
                    (unsigned)need, (unsigned)heap, (unsigned)largest);
}
